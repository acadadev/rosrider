Commit message: L0

File: rosrider_description/urdf/duckiebot.urdf (robot description, URDF)
Before this commit: robot duckiebot, 8 links, 7 joints
Joints:
- joint wheel_castor_joint: origin xyz=-0.095 0 -0.02425 rpy=0 0 0 -> xyz=-0.09185 0 -0.02425 rpy=0 0 0
