Commit message: refactor 4

File: rosrider_description/urdf/duckiebot_gz.urdf (robot description, URDF)
Before this commit: robot duckiebot, 9 links, 8 joints
Joints:
- joint wheel_castor_joint: type fixed -> continuous
- joint wheel_steering_joint: type fixed -> continuous
